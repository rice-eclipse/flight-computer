# Repository rice-eclipse/flight-computer

File README.md:

# Strix
Custom STM32-Based flight computer to gather data from IMUs, altimeters, and GPS, and control in-flight pyrotechnic events. The software running on this board was created in STM32CubeMX, and stored in a different repository.

This repository contains KiCAD schematics and layouts for this flight computer. The schematics use hierarchical schematic sheets, with sheets defined for the microcontroller, sensors/data storage, pyrotechnic channels, connectors, and power supply.

## Notes
Manufacturing exports go in the fabrication folder (ignored by .gitignore)

## Additional Documentation:
[docs/strix.md](docs/strix.md)

## KiCad design Flight Computer.kicad_pcb

Board: 4 copper layers, 39.0 x 72.9 mm, 135 parts (22 on the bottom side), 101 nets.

Parts:
BZ1: Buzzer; Buzzer_TDK_PS1240P02BT_D12.2mm_H6.5mm
C1, C2, C3, C4, C5, C8, C9, C11, C12, C13, C14, C15, C16, C17, C18, C19, C25, C29: 100n; C_0402_1005Metric
C6, C10: 12p; C_0402_1005Metric
C7: 4u7; C_0603_1608Metric
C24: 1u; C_0603_1608Metric
C26: 2.2u; C_0603_1608Metric
C27: 33pF; C_0402_1005Metric
C30: 10u; C_0805_2012Metric
D1: Blue; LED_0603_1608Metric
D2: Green; LED_0603_1608Metric
D3, D4, D5, D6, D7, D8: Red; LED_0603_1608Metric
D9, D10, D11, D12, D13, D14: White; LED_0603_1608Metric
D15: D_Schottky; D_SOD-323
F2: 2920L125PR; Fuse_0805_2012Metric
FB1, FB3: GZ2012D601TF; L_0805_2012Metric
J1: Screw Switches; Pheonix-Contact-1861991
J2: Pyro Channels; Pheonix-Contact-1861991
J3: External SPI; Molex_PicoBlade_53048-0510_1x05_P1.25mm_Horizontal
J4: JST-PH; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J5: USB_B_Micro; USB_Micro-B_Amphenol_10118194_Horizontal
J8: External UART; Molex_PicoBlade_53048-0410_1x04_P1.25mm_Horizontal
J9: External I2C; Molex_PicoBlade_53048-0410_1x04_P1.25mm_Horizontal
L3: 1u; L_Sunlord_SWPA4030S
Q1: MMBT2222A; SOT-23
Q2, Q3, Q5, Q6, Q7, Q8: AO3400A; SOT-23
R1, R4, R7, R9, R11, R13, R15, R25: 200k; R_0402_1005Metric
R2: 47; R_0603_1608Metric
R3: 10k; R_0402_1005Metric
R5: 47k; R_0402_1005Metric
R6, R8, R10, R12, R14, R16, R29, R30, R31, R32, R33, R34, R35: 22k; R_0402_1005Metric
R17, R24, R36, R37, R38, R39, R40, R41, R47, R56, R57, R58, R59, R60: 1k; R_0402_1005Metric
R18, R28: 1k; R_0603_1608Metric
R19: 1M; R_0402_1005Metric
R22: 12k; R_0402_1005Metric
R26, R27: 4.7k; R_0402_1005Metric
R45, R46: 100k; R_0402_1005Metric
SW1: USB Disconnect; SW_SPDT_PCM12
SW2: Screw Switch Bypass; SW_SPDT_PCM12
TP1: Buck In; TestPoint_Pad_D1.5mm
TP2: 3.3V; TestPoint_Pad_D1.5mm
TP3: SPI1 MISO; TestPoint_Pad_D1.5mm
TP4: SPI1 MOSI; TestPoint_Pad_D1.5mm
TP5: SPI1 SCK; TestPoint_Pad_D1.5mm
TP6: CS Altimeter; TestPoint_Pad_D1.5mm
TP7: SPI2 MISO; TestPoint_Pad_D1.5mm
TP8: CS Low G Gyro; TestPoint_Pad_D1.5mm
TP9: CS Low G Accel; TestPoint_Pad_D1.5mm
TP10: UART2 TX; TestPoint_Pad_D1.5mm
TP11: UART2 RX; TestPoint_Pad_D1.5mm
TP12: Gnd; TestPoint_Pad_D1.5mm
TP13: SPI2 MOSI; TestPoint_Pad_D1.5mm
TP14: SPI2 SCK; TestPoint_Pad_D1.5mm
TP15: QSPI Clock; TestPoint_Pad_D1.5mm
TP16: CS High G Accel; TestPoint_Pad_D1.5mm
TP17: CS Magnetometer; TestPoint_Pad_D1.5mm
U1: STM32L476VETx; LQFP-100_14x14mm_P0.5mm
U2: USBLC6-2SC6; SOT-23-6
U4: BMI088
U5: BMP388
U6: SOT-563
U7: W25Q128JVSIQ; SOIC-8_5.23x5.23mm_P1.27mm
U8: MAX40200AUK; SOT-23-5
U9: LIS3MDL; LGA-12_2x2mm_P0.5mm
U10: KX134-1211
U11: SAM-M8Q; ublox_SAM-M8Q_HandSolder
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: BZ1.1 (-), C1.1, C2.1, C3.1, C4.1, C5.1, C7.1, C8.1, C9.1, C11.1, C12.1, C13.1, C14.1, C15.1, C17.1, C18.1, C27.1, C29.1, C30.1, D2.2 (A), FB1.2, J3.1, J9.1, L3.2, R22.1, R26.1, R27.1, R28.1, TP2.1, U1.6 (VBAT), U1.11 (VDD), U1.28 (VDD), U1.50 (VDD), U1.73 (VDDUSB), U1.75 (VDD), U1.100 (VDD), U4.3 (Vdd), U4.11 (Vddio), U5.1 (Vddio), U5.10 (Vdd), U7.8 (VCC), U9.5 (Vdd), U9.6 (Vdd_IO), U10.3 (IO_Vdd), U10.7 (Vdd), U11.2 (VCC_IO), U11.17 (VCC)
+12V: J1.3, J1.4, J1.7, J1.8, J1.13, J1.14, J2.1, J2.2, J2.5, J2.6, J2.9, J2.10, J2.13, J2.14, R25.1
/Altimeter Interrupt: U1.98 (PE1), U5.7 (Interrupt)
/Chip Select Altimeter: TP6.1, U1.97 (PE0), U5.6 (Chip_Select)
/Chip Select Low G Accel: TP8.1, U1.93 (PB7), U4.14 (Chip_Select_Accel)
/Chip Select Low G Gyro: TP9.1, U1.95 (PB8), U4.5 (Chip_Select_Gyro)
/Connectors and Power Supply/Power Supply/Buck_SW: L3.1, U6.4 (SW)
/Connectors and Power Supply/Power Supply/Buck_VIN: C26.1, F2.2, U6.3 (VIN), U6.5 (Enable)
/Connectors and Power Supply/USB CONN D+: J5.3 (D+), U2.3 (I/O2)
/Connectors and Power Supply/USB CONN D-: J5.2 (D-), U2.1 (I/O1)
/Connectors and Power Supply/Vin_combined: FB3.1, J8.1, SW1.1 (A), TP1.1, U8.5 (OUT)
/GPS External Interrupt: U1.84 (PD3), U11.19 (EXTINT)
/GPS Reset: U1.85 (PD4), U11.18 (~RESET)
/High G Accel Chip Select: TP16.1, U1.83 (PD2), U10.10 (nCS)
/High G Accel Interrupt: U1.82 (PD1), U10.5 (Int_1)
/I2C2 SCL: J9.3, R26.2, U1.47 (PB10)
/I2C2 SDA: J9.2, R27.2, U1.48 (PB11)
/Ignition Battery Voltage: R25.2, R35.1, U1.33 (PC4)
/Low G Accel Interrupt: U1.96 (PB9), U4.16 (Interrupt_1)
/Low G Gyro Interrupt: U1.92 (PB6), U4.12 (Interrupt_3)
/Magnetometer Chip Select: TP17.1, U1.77 (PA15), U9.10 (~CS)
/Magnetometer Interrupt: U1.81 (PD0), U9.7 (INT)
/Main battery connector: J1.9, J1.10, J4.2, SW2.2 (B)
/Main battery in: J1.11, J1.12, SW2.1 (A), U8.1 (VDD), U8.3 (EN)
/Microcontroller/VDDA: C16.1, C24.1, FB1.1, U1.21 (VREF+), U1.22 (VDDA)
/NRST: J3.2, U1.14 (NRST)
/Pyro A Continuity LED: R47.1, U1.58 (PD11)
/Pyro A Continuity Voltage: R4.2, R6.1, U1.23 (PA0)
/Pyro B Continuity LED: R56.1, U1.57 (PD10)
/Pyro B Continuity Voltage: R7.2, R8.1, U1.24 (PA1)
/Pyro C Continuity LED: R57.1, U1.54 (PB15)
/Pyro C Continuity Voltage: R9.2, R10.1, U1.25 (PA2)
/Pyro Channel A Trigger: Q2.1 (G), R34.1, R36.1, U1.37 (PB2)
/Pyro Channel B Trigger: Q3.1 (G), R29.1, R40.1, U1.38 (PE7)
/Pyro Channel C Trigger: Q5.1 (G), R33.1, R41.1, U1.39 (PE8)
/Pyro Channel D Trigger: Q8.1 (G), R32.1, R39.1, U1.40 (PE9)
/Pyro Channel E Trigger: Q6.1 (G), R30.1, R37.1, U1.44 (PE13)
/Pyro Channel F Trigger: Q7.1 (G), R31.1, R38.1, U1.43 (PE12)
/Pyro D Continuity LED: R58.1, U1.53 (PB14)
/Pyro D Continuity Voltage: R15.2, R16.1, U1.26 (PA3)
/Pyro E Continuity LED: R59.1, U1.59 (PD12)
/Pyro E Continuity Voltage: R11.2, R12.1, U1.30 (PA5)
/Pyro F Continuity LED: R60.1, U1.60 (PD13)
/Pyro F Continuity Voltage: R13.2, R14.1, U1.29 (PA4)
/Pyrotechnic Channels/Pyro Channel A: J2.3, J2.4, Q2.3 (D), R4.1
/Pyrotechnic Channels/Pyro Channel B: J2.7, J2.8, Q3.3 (D), R7.1
/Pyrotechnic Channels/Pyro Channel C: J2.11, J2.12, Q5.3 (D), R9.1
/Pyrotechnic Channels/Pyro Channel D: J2.15, J2.16, Q8.3 (D), R15.1
/Pyrotechnic Channels/Pyro Channel E: J1.1, J1.2, Q6.3 (D), R11.1
/Pyrotechnic Channels/Pyro Channel F: J1.5, J1.6, Q7.3 (D), R13.1
/QSPI Chip Select: U1.42 (PE11), U7.1 (~CS)
/QSPI Clock: TP15.1, U1.41 (PE10), U7.6 (CLK)
/QSPI IO0: U1.36 (PB1), U7.5 (DI(IO0))
/QSPI IO1: U1.35 (PB0), U7.2 (DO(IO1))
/QSPI IO2: U1.32 (PA7), U7.3 (IO2)
/QSPI IO3: U1.31 (PA6), U7.7 (IO3)
/SPI1 MISO: TP3.1, U1.90 (PB4), U4.10 (SDO2), U4.15 (SDO1), U5.5 (SDO)
/SPI1 MOSI: TP4.1, U1.91 (PB5), U4.9 (SDA/SDI), U5.4 (SDI)
/SPI1 SCK: TP5.1, U1.89 (PB3), U4.8 (SCL/SCK), U5.2 (SCK)
/SPI3 MISO: TP14.1, U1.79 (PC11), U9.9 (SDO/SA1), U10.1 (SDO/ADDR)
/SPI3 MOSI: TP13.1, U1.80 (PC12), U9.11 (SDA/SDI/SDO), U10.2 (SDI/SDA)
/SPI3 SCK: TP7.1, U1.78 (PC10), U9.1 (SCL/SPC), U10.12 (SCK)
/SWCLK: J3.3, U1.76 (PA14)
/SWDIO: J3.4, U1.72 (PA13)
/UART2 RX: TP11.1, U1.87 (PD6), U11.13 (TXD)
/UART2 TX: TP10.1, U1.86 (PD5), U11.14 (RXD)
/UART3 RX: J8.2, U1.56 (PD9)
/UART3 TX: J8.3, U1.55 (PD8)
/USB 5V in: D15.2 (A), J5.1 (VBUS), R45.1, U2.5 (VBUS)
/USB D+: U1.71 (PA12), U2.4 (I/O2)
/USB D-: U1.70 (PA11), U2.6 (I/O1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C24.2, C25.2, C26.2, C29.2, C30.2, D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), J1.15, J1.16, J3.5, J4.1, J5.5 (GND), J8.4, J9.4, Q1.2 (E), Q2.2 (S), Q3.2 (S), Q5.2 (S), Q6.2 (S), Q7.2 (S), Q8.2 (S), R3.1, R5.2, R6.2, R8.2, R10.2, R12.2, R14.2, R16.2, R17.2, R19.2, R24.2, R29.2, R30.2, R31.2, R32.2, R33.2, R34.2, R35.2, R46.2, TP12.1, U1.10 (VSS), U1.19 (VSSA), U1.20 (VREF-), U1.27 (VSS), U1.49 (VSS), U1.74 (VSS), U1.99 (VSS), U2.2 (GND), U4.2 (NC), U4.4 (GNDA)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
unnamed: BZ1.2 (+), Q1.3 (C), R28.2
unnamed: C10.1, R2.2, Y1.3
unnamed: D1.2 (A), U1.61 (PD14)
unnamed: D1.1 (K), R17.1
unnamed: D2.1 (K), R24.1
unnamed: D3.2 (A), R36.2
unnamed: D4.2 (A), R37.2
unnamed: D5.2 (A), R38.2
unnamed: D6.2 (A), R39.2
unnamed: D7.2 (A), R40.2
unnamed: D8.2 (A), R41.2
unnamed: D9.2 (A), R47.2
unnamed: D10.2 (A), R56.2
unnamed: D11.2 (A), R57.2
unnamed: D12.2 (A), R58.2
unnamed: D13.2 (A), R59.2
unnamed: D14.2 (A), R60.2
unnamed: D15.1 (K), SW1.2 (B)
unnamed: F2.1, FB3.2
unnamed: C25.1, J5.6 (Shield), R19.1
unnamed: Q1.1 (B), R18.2
unnamed: R1.1, R22.2
unnamed: R3.2, U1.94 (BOOT0)
unnamed: R45.2, R46.1, U1.68 (PA9)
unnamed: R18.1, U1.46 (PE15)
unnamed: C6.1, U1.12 (PH0), Y1.1
unnamed: R2.1, U1.13 (PH1)
unnamed: C27.2, R1.2, R5.1, U6.1 (FB)
unnamed: C19.1, U9.4 (C1)

## Commit log

2023-09-19 Added symbols for sensors and power supply
2023-09-20 Finished Updating Sensor Schematics
2023-09-23 Added power supply circuitry, as well as example pyrotechnic channel MOSFET
2023-09-24 Schematics are love. Also I have no idea what I was doing last night so the power supply might be terrible, but I know I thought it was brilliant at the time
2023-09-24 Began configuring STM32F476
2023-09-25 add microsd + flash schematics
2023-09-25 173 Errors. I'm going to take a break
2023-09-25 Fixed all correct errors
2023-09-26 Chose footprints for most components
2023-09-27 Added custom footprints and started layout
2023-09-27 Started footprint
2023-09-28 Made more progress on layout
2023-09-28 I sure hope I come up with a better layout than this for the pyro channels
2023-09-28 Finished first draft of layout
2023-09-28 add Clayton's notes on the flight computer
2023-09-29 How many sheets do you want? Yes
2023-09-29 Finished updating the schematics
2023-09-30 Started doing layout for v1.1
2023-10-01 finished layout for v1.1
2023-10-05 How many test points do you want? Yes.
2023-10-05 Now with 100% fewer faulty flyback diodes
2023-10-10 Updated BOM
2023-10-10 Updated to match JLC manufacturing capabilities
2023-10-11 More JLC stuff
2023-10-13 Updated with notes from Erik Welsh
2023-10-14 KiCAD is broken
2023-10-15 Fabrication outputs
2023-10-18 Minore changes and updates
2023-10-19 Fixed battery polarity
2023-10-19 Updating with notes from Adam
2023-10-21 Finished final(tm) updates for v1.1
2023-10-21 Added logo and 3D model for 5-pin picoblade
2023-10-21 Started updating documentation
2023-10-21 continued documentation writing
2023-10-22 Added old version of BOM
2023-10-22 Cleaning up 3d files
2023-10-22 Adding gitignore file
2023-10-22 Sometimes I hate Git
2023-10-22 Removing files
2023-10-22 Continued cleaning things up
2023-10-22 Added new footprint for pyrotechnic channels
2023-10-22 Finished layout with modified pyro terminal blocks
2023-10-23 Added different 3d models for terminal blocks
2023-10-28 Modified connector footprints
2023-10-28 Adding images for documentation
2023-10-28 Update strix.md
    Attempting to put images next to each other
2023-11-13 Match what was sent to JLC
2023-11-14 Added new buck converter
2023-11-15 finished preliminary v2 modifications
2023-11-19 added switch to USB power and to bypass screw switch for main battery
2023-11-20 Fixed BOM
2023-11-21 Finished DRC
2023-11-23 Remove old BOM
2023-11-23 Added fabircation outputs for v1.2 and v2
2023-11-30 Minor changes to fit jlc capabilities
2023-11-30 Changed Vreg to 3.3 volts from 3.15
2023-12-01 Double checking BOM
2023-12-01 Exported fabrication outputs
2023-12-01 ran cleanup tracks tool
2024-01-22 Swapped out sensors in schematic for v3
2024-01-22 STarted layout for v3
2024-01-22 Finished preliminary layout of v3
2024-01-25 Finished layout of v3
2024-02-05 Syncing
