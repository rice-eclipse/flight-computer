File: connectors.kicad_sch (KiCad schematic)
At the start: 34 parts, among them J2 Pyro Channels, J3 Screw Switches, J4 JST-PH, J5 JST-GH, J6 Serial Wire Debug, J7 USB_C_Receptacle_USB2.0, J8 External UART, J9 External I2C, Q10 AO3401A, Q9 AO3401A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

Commit message: Fixed all correct errors
Connections:
- net 5V Out Main Battery is gone; now on net +5V: C20.1, C22.1, C23.1, FB2.1, Q10.2 (S), R23.1, R25.1, U8.3 (VOUT), U8.4 (VOUT)

Commit message: Chose footprints for most components
Parts:
- removed BT1: Battery_Cell, symbol Device:Battery_Cell
- removed J5: JST-GH, symbol Connector_Generic:Conn_01x02
- C17, C20, C21, C22, C23: footprint (none) -> Capacitor_SMD:C_0805_2012Metric
- C18: footprint (none) -> Capacitor_SMD:C_0402_1005Metric
- C19: footprint (none) -> Capacitor_SMD:C_0603_1608Metric
- D2: footprint (none) -> LED_SMD:LED_0805_2012Metric
- FB2: footprint (none) -> Inductor_SMD:L_0805_2012Metric
- J4: footprint (none) -> Connector_JST:JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
- J6: footprint (none) -> Connector_PinHeader_2.54mm:PinHeader_2x05_P2.54mm_Vertical_SMD
- J7: footprint (none) -> Connector_USB:USB_C_Receptacle_G-Switch_GT-USB-7010ASV
- J8, J9: footprint (none) -> Connector_Molex:Molex_PicoBlade_53048-0410_1x04_P1.25mm_Horizontal
- R17: value R -> 220k; footprint (none) -> Resistor_SMD:R_0402_1005Metric
- R18: value R -> 22k; footprint (none) -> Resistor_SMD:R_0402_1005Metric
- R19, R23, R24, R5: footprint (none) -> Resistor_SMD:R_0603_1608Metric
- R20, R21, R22, R25: footprint (none) -> Resistor_SMD:R_0402_1005Metric
Other:
- note removed: "Backup Battery"
- note removed: "There are two different main battery connectors, one JST-PH2.0 and one JST-GH1.25"

Commit message: Added custom footprints and started layout
Parts:
- added U10: SRV05-4, Package_TO_SOT_SMD:SOT-23-6, symbol Power_Protection:SRV05-4
- J2, J3: footprint (none) -> custom-footprints:Wago_Custom_218-108
- J6: footprint Connector_PinHeader_2.54mm:PinHeader_2x05_P2.54mm_Vertical_SMD -> Connector_PinHeader_2.54mm:PinHeader_1x05_P2.54mm_Horizontal; symbol Connector_Generic:Conn_02x05_Odd_Even -> Connector_Generic:Conn_01x05
- L3, L4: footprint (none) -> Inductor_SMD:L_Sunlord_SWPA4030S
- R20, R21: value 5.1k -> 4.7k
Connections:
- net GND: now also U10.2 (VN); no longer J6.3 (Pin_3), J6.9 (Pin_9)
- net NRST: now also J6.4 (Pin_4); no longer J6.10 (Pin_10)
- net SWCLK: now also J6.3 (Pin_3); no longer J6.4 (Pin_4)
- net USB 5V In: now also U10.5 (VP)
- net USB D+: now also U10.3 (IO2)
- net USB D-: now also U10.1 (IO1)
- removed net SWO: J6.6 (Pin_6)
Other:
- moved on the sheet: J8, J9

Commit message: Started footprint
Parts:
- removed U10: SRV05-4, Package_TO_SOT_SMD:SOT-23-6, symbol Power_Protection:SRV05-4
- added H1, H2, H3, H4: MountingHole, MountingHole:MountingHole_2mm, symbol Mechanical:MountingHole
- added U2: USBLC6-2SC6, Package_TO_SOT_SMD:SOT-23-6, symbol Power_Protection:USBLC6-2SC6
- R17: value 220k -> 200k
- R19: footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0402_1005Metric
- R23: value 220k -> 200k; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0402_1005Metric
- R24: value 51k -> 47k; footprint Resistor_SMD:R_0603_1608Metric -> Resistor_SMD:R_0402_1005Metric
Connections:
- net +3.3V: now also J9.1 (Pin_1)
- net +5V: no longer J9.1 (Pin_1)
- net GND: now also U2.2 (GND)
- net USB 5V In: now also U2.5 (VBUS)
- net USB D+: now also U2.4 (I/O2); no longer J7.A6 (D+), J7.B6 (D+)
- net USB D-: now also U2.6 (I/O1); no longer J7.A7 (D-), J7.B7 (D-)
- net Vin Buck Converter: now reaches C19.1, FB2.2, U9.1 (Vin), U9.3 (EN)
- net Switch Buck Converter: now reaches L4.1, U9.5 (SW)
- new net USB CONN D+: J7.A6 (D+), J7.B6 (D+), U2.3 (I/O2)
- new net USB CONN D-: J7.A7 (D-), J7.B7 (D-), U2.1 (I/O1)
- no-connect marks 5 -> 3

Commit message: Made more progress on layout
Parts:
- R20, R21: value 4.7k -> 5.1k; footprint Resistor_SMD:R_0402_1005Metric -> Resistor_SMD:R_0603_1608Metric
Connections:
- net USB 5V In renamed USB 5V in
Changed lines of the file:
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@@
   (junction (at 41.91 97.79) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 66.04 137.16) (diameter 0) (color 0 0 0 0)
   )
   (junction (at 49.53 34.29) (diameter 0) (color 0 0 0 0)
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 48.26 137.16) (xy 67.31 137.16))
+  (wire (pts (xy 48.26 137.16) (xy 66.04 137.16))
     (stroke (width 0) (type default))
   )
@@
   )
   (wire (pts (xy 22.86 66.04) (xy 22.86 67.31))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 71.12 137.16) (xy 66.04 137.16))
     (stroke (width 0) (type default))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left))
   )
+  (hierarchical_label "USB 5V in" (shape input) (at 71.12 137.16 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left))
+  )
   (hierarchical_label "Pyro Channel D" (shape input) (at 66.04 110.49 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
@@
     )
   )
-  (symbol (lib_id "power:PWR_FLAG") (at 67.31 137.16 270) (unit 1)
+  (symbol (lib_id "power:PWR_FLAG") (at 66.04 137.16 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "#FLG02" (at 69.215 137.16 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "PWR_FLAG" (at 71.12 137.16 90)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "" (at 67.31 137.16 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 67.31 137.16 0)
+    (property "Reference" "#FLG02" (at 66.04 135.255 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "PWR_FLAG" (at 62.23 133.35 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "" (at 66.04 137.16 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 66.04 137.16 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "4.7k" (at 78.74 152.4 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "Resistor_SMD:R_0402_1005Metric" (at 75.692 151.13 90)
+    (property "Value" "5.1k" (at 78.74 152.4 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 75.692 151.13 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "4.7k" (at 71.12 152.4 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "Resistor_SMD:R_0402_1005Metric" (at 68.072 151.13 90)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Value" "5.1k" (at 71.12 152.4 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Resistor_SMD:R_0603_1608Metric" (at 68.072 151.13 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
